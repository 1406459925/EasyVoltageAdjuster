# IAR project USB_Power.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Power.hex
  ILINK.IlinkOutputFile: USB_Power.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: ./User
  group (top)
    ./: main.c
    User/: type.h
  group Config
    User/: config.c config.h eeprom.c eeprom.h
  group ControllerIV
    User/: controller.c controller.h pid.c pid.h
  group DIsplay
    User/: 74hc595.c 74hc595.h display.c display.h menu.c menu.h
  group Infraed
    User/: infrared.c infrared.h
  group Key
    User/: key.c key.h
  group Measure
    User/: adc.c adc.h
  group PWM
    User/: tim.c tim.h
  group Share
    User/: share.c share.h
  group Temperature
    User/: temp.c temp.h
